# Keil uVision project ds1307.uvproj, settings and files
target QD-TFT (MCS-51)
  device: C8051F380 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\font;.\LCD;.\sys;.\touch;.\GUI;.\USER
  group USER
    ./: MP3.h UART1.h main.c init380.c ds1307.c i2cFunction.c SYS19_v2.LIB main_display.c RTC_fun.c time_fun.c hour_setup.c min_setup.c sec_setup.c input_key_bord.c date_page.c day_setup.c date_setup.c month_setup.c year_setup.c reminder_page.c rem_hour_setup.c rem_min_setup.c uart.c uart1.c sendcmptomp3.c input_12_key_bord.c clock_reader.c AHT10.h functions_AHT10.c
